;Spice netlist for an inverter and a capacitor
simulator lang=spectre

include "~/cadence/cellcharacs/model18.spi"
include "~/cadence/cellcharacs/cell18.spi"

vgnd (gnd 0) vsource dc=0
vvdd (vdd 0) vsource dc=1.8

acinput (XOR2_in 0) vsource dc=0 mag=1

R1 (XOR2_in XOR2_in1) resistor r=0

//    A      B   output    VDD GND
X1 (XOR2_in1 vdd XOR2_out vdd gnd) XOR2 wp=9u lp=0.4u wn=2.5u ln=0.5u

Freq ac start=1e+1 stop=1e+9
save R1:currents
